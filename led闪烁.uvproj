# Keil uVision project led闪烁.uvproj, settings and files
target Target 1 (MCS-51)
  device: see Microchip Atmel Wireless & uC
  output: led闪烁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led闪烁.c
